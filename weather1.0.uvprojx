# Keil uVision project weather1.0.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: weather1.0
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c adc.c lcd.c systick.c uart.c esp8266.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.6.3
